# Keil uVision project Mystic.uvproj, settings and files
target Mystic (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Mystic +hex
  c flags: OneElfS=1
  c include: ..\Libraries\LPC1700CMSIS_Firmware_Library\include;..\Libraries\CM3\DeviceSupport\NXP\LPC17xx;..\Source;..\Source\SPI_SD_Card;..\Source\FATFS_V0.08A\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Main
    ../Source/: main.c timer.c timer.h
  group SPI_SD_Card
    ../Source/SPI_SD_Card/: SPI_MSD_Driver.c
  group Startup
    ../Source/Platform/LPC17xx/startup/arm/: startup_LPC17xx.s
  group Kernel
    ../Source/Kernel/: Config.h Kernel.c Kernel.h Utilities.h FileSystem.c FileSystem.h Types.h List.c Execute.c Process.h Process.c Time.c Time.h RTC.c RTC.h Info.txt UART.c Thread.c
  group Graphics
    ../Source/Graphics/: Graphics.c Graphics.h Screen.c AsciiLib.c AsciiLib.h
  group Platform
    ../Source/Platform/: Procesor_CPU.c Procesor_CPU.h
  group LPC17xx
    ../Source/Platform/LPC17xx/: debug_frmwrk.c lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c system_LPC17xx.c
    ../Source/Platform/LPC17xx/Cortex M3/: core_cm3.c
  group FatFs
    ../Source/FatFs/: diskio.c ff.c ffconf.h
    ../Source/FatFs/option/: ccsbcs.c
